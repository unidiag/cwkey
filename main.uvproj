# Keil uVision project main.uvproj, settings and files
target CWKEY (MCS-51)
  device: STC15W204S STC
  cpu: IRAM(0-0xFF) IROM(0-0x0FF8) CLOCK(35000000) MODP2
  output: main +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c i2c.h
